# Keil uVision project project.uvproj, settings and files
target RTThread (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;STM32F4xx_Libraries\CMSIS\Include;STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;applications;drivers;rt-thread\components\dfs;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\include;rt-thread\components\drivers\include;rt-thread\components\external\jpeg;rt-thread\components\finsh;rt-thread\components\init;rt-thread\components\net\lwip\src;rt-thread\components\net\lwip\src\arch\include;rt-thread\components\net\lwip\src\include;rt-thread\components\net\lwip\src\include\ipv4;rt-thread\components\net\lwip\src\include\netif;rt-thread\components\pthreads;rt-thread\components\rtgui\common;rt-thread\components\rtgui\include;rt-thread\components\rtgui\server;rt-thread\components\rtgui\widgets;rt-thread\include;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c libc_export.c setup.c startup.c
  group Drivers
    drivers/: board.c platform.c usart.c ext_sram.c stm32f4xx_it.c stm32f4xx_sd.c stm32f4xx_eth.c stm32f20x_40x_spi.c spi_flash_w25qxx.c ra8875.c key.c touch.c
  group STM32_StdPeriph
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group ui
    ui/: appmgr.c apps_list.c block_panel.c calibration.c ex_app.c picture.c program.c realtouch_ui.c statusbar.c
  group Kernel
    rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: cc936.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c console.c
  group DeviceDrivers
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c ringbuffer.c
  group jpeg
    rt-thread/components/external/jpeg/: jaricom.c jcomapi.c jutils.c jerror.c jmemmgr.c jdapimin.c jdapistd.c jdarith.c jdtrans.c jdmaster.c jdinput.c jdmarker.c jdhuff.c jdmainct.c jdcoefct.c jdpostct.c jddctmgr.c jidctfst.c jidctflt.c jidctint.c jdsample.c jdcolor.c jquant1.c jquant2.c jdmerge.c jmemnobs.c
  group finsh
    rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Components
    rt-thread/components/init/: components_init.c
  group LwIP
    rt-thread/components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/src/arch/: sys_arch.c sys_arch_init.c
    rt-thread/components/net/lwip/src/core/: dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    rt-thread/components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    rt-thread/components/net/lwip/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group pthreads
    rt-thread/components/pthreads/: clock_time.c mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
  group RTGUI
    rt-thread/components/rtgui/common/: blit.c color.c region.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c rtgui_app.c dc.c dc_hw.c dc_buffer.c dc_client.c filerw.c image.c image_xpm.c image_hdc.c image_bmp.c image_png.c image_jpg.c image_container.c font.c font_bmp.c font_hz_file.c font_hz_bmp.c asc12font.c asc16font.c hz12font.c hz16font.c framebuffer_driver.c pixel_driver.c
    rt-thread/components/rtgui/server/: driver.c mouse.c server.c topwin.c
    rt-thread/components/rtgui/widgets/: box.c button.c checkbox.c combobox.c iconbox.c label.c textview.c listctrl.c menu.c progressbar.c radiobox.c slider.c scrollbar.c staticline.c textbox.c listbox.c title.c notebook.c container.c list_view.c filelist_view.c widget.c window.c panel.c groupbox.c edit.c
